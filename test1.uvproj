# Keil uVision project test1.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\STM32_CMSIS;.\STM32_CMSIS\CoreSupport;.\STM32_CMSIS\DeviceSupport\ST\STM32F10x;.\STM32_SPL;..\ARM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group CMSIS
    ./STM32_CMSIS/CoreSupport/: core_cm3.c
    ./STM32_CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SPL
    ./STM32_SPL/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group Sources
    ./: test1.c
